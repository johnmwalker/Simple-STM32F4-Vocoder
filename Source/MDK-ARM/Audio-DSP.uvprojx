# Keil uVision project Audio-DSP.uvprojx, settings and files
target Audio-DSP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Audio-DSP
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX, __FPU_PRESENT, ARM_MATH_CM4
  c include: ..\inc;..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Utilities\Third_Party\fat_fs\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\PyinSource
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c headphone.c microphone.c dsp.c delay.c dywapitchtrack.c LCD.c
    ./: PSOLA.c ADC.c
  group STM32F4-Discovery
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c libPDMFilter_Keil.lib
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_rng.c stm32f4xx_adc.c stm32f4xx_tim.c
    ./../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dac.c stm32f4xx_exti.c
  group MDK-ARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../Libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
